# Keil uVision project Project.uvproj, settings and files
target STM32-IIC-EVAL (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: AD5933_TEST +hex
  AfterMake: fromelf --bin --output=app.bin .\obj\AD5933_TEST.axf
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c include: ..\Project;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Utilities\stm32_eval;..\Utilities\stm32_eval\IIC;..\Utilities\stm32_eval\SPI;..\Utilities\stm32_eval\AD5933;..\Utilities\stm32_eval\wave;..\Utilities\stm32_eval\delay;..\Utilities\stm32_eval\calculate;..\Utilities\stm32_eval\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ./: stm32f10x_it.c main.c
    ../Utilities/stm32_eval/calculate/: Calculate.c
  group CMSIS
    ./: system_stm32f10x.c
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32_EVAL
    ../Utilities/stm32_eval/AD5933/: AD5933.c
    ../Utilities/stm32_eval/IIC/: stm32_eval_iic.c
    ../Utilities/stm32_eval/: stm32_eval.c
    ../Utilities/stm32_eval/SPI/: stm32_eval_spi.c
    ./: configure_init.c
    ../Utilities/stm32_eval/delay/: stm32_delay.c
    ../Utilities/stm32_eval/wave/: stm32_eval_wave.c
    ../Utilities/stm32_eval/PWM/: pwm.c
    ../Utilities/stm32_eval/DMA/: dma.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md_vl.s
  group Doc
    ./: readme.txt
